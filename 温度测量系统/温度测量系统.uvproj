# Keil uVision project 温度测量系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 温度测量系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group Source Group 1
    ./: STARTUP.A51 main.c
  group driver
    ./driver/: DS18B20.c LCD1602.c HC_05.c
